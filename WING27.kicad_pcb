# Repository HSBL-ko-gyo/WING27

File README.md:

# WING27

[回路図・PCBをブラウザで見る（KiCanvas）](https://kicanvas.org/?repo=https://github.com/HSBL-ko-gyo/WING27)

## KiCad design WING27.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30: BAV70; SOT-23; manufacturer_pn BAV70; LCSC C68978
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47, SW48, SW49, SW50, SW51, SW52, SW53, SW54, SW55, SW56, SW57, SW58, SW59, SW60: CMI627301D60; Kailh_CMI627301D60; manufacturer_pn CMI627301D60

Connections:
/KEY_L1_1: D1.1 (A), SW1.2
/KEY_L1_2: D1.2 (A), SW2.2
/KEY_L1_3: D2.1 (A), SW3.2
/KEY_L1_4: D2.2 (A), SW4.2
/KEY_L1_5: D3.1 (A), SW5.2
/KEY_L1_6: D3.2 (A), SW6.2
/KEY_L2_1: D7.1 (A), SW7.2
/KEY_L2_2: D7.2 (A), SW8.2
/KEY_L2_3: D8.1 (A), SW9.2
/KEY_L2_4: D8.2 (A), SW10.2
/KEY_L2_5: D9.1 (A), SW11.2
/KEY_L2_6: D9.2 (A), SW12.2
/KEY_L3_1: D13.1 (A), SW13.2
/KEY_L3_2: D13.2 (A), SW14.2
/KEY_L3_3: D14.1 (A), SW15.2
/KEY_L3_4: D14.2 (A), SW16.2
/KEY_L3_5: D15.1 (A), SW17.2
/KEY_L3_6: D15.2 (A), SW18.2
/KEY_L4_1: D19.1 (A), SW19.2
/KEY_L4_2: D19.2 (A), SW20.2
/KEY_L4_3: D20.1 (A), SW21.2
/KEY_L4_4: D20.2 (A), SW22.2
/KEY_L4_5: D21.1 (A), SW23.2
/KEY_L4_6: D21.2 (A), SW24.2
/KEY_L5_1: D25.1 (A), SW25.2
/KEY_L5_2: D25.2 (A), SW26.2
/KEY_L5_3: D26.1 (A), SW27.2
/KEY_L5_4: D26.2 (A), SW28.2
/KEY_L5_5: D27.1 (A), SW29.2
/KEY_L5_6: D27.2 (A), SW30.2
/KEY_R1_1: D4.1 (A), SW31.2
/KEY_R1_2: D4.2 (A), SW32.2
/KEY_R1_3: D5.1 (A), SW33.2
/KEY_R1_4: D5.2 (A), SW34.2
/KEY_R1_5: D6.1 (A), SW35.2
/KEY_R1_6: D6.2 (A), SW36.2
/KEY_R1_7: D12.1 (A), SW37.2
/KEY_R2_1: D10.1 (A), SW38.2
/KEY_R2_2: D10.2 (A), SW39.2
/KEY_R2_3: D11.1 (A), SW40.2
/KEY_R2_4: D11.2 (A), SW41.2
/KEY_R2_5: D18.1 (A), SW42.2
/KEY_R2_6: D12.2 (A), SW43.2
/KEY_R3_1: D16.1 (A), SW44.2
/KEY_R3_2: D16.2 (A), SW45.2
/KEY_R3_3: D17.1 (A), SW46.2
/KEY_R3_4: D17.2 (A), SW47.2
/KEY_R3_5: D18.2 (A), SW48.2
/KEY_R4_1: D22.1 (A), SW49.2
/KEY_R4_2: D22.2 (A), SW50.2
/KEY_R4_3: D23.1 (A), SW51.2
/KEY_R4_4: D23.2 (A), SW52.2
/KEY_R4_5: D24.1 (A), SW53.2
/KEY_R4_6: D24.2 (A), SW54.2
/KEY_R5_1: D28.1 (A), SW55.2
/KEY_R5_2: D28.2 (A), SW56.2
/KEY_R5_3: D29.1 (A), SW57.2
/KEY_R5_4: D29.2 (A), SW58.2
/KEY_R5_5: D30.1 (A), SW59.2
/KEY_R5_6: D30.2 (A), SW60.2
COL0: SW1.1, SW7.1, SW13.1, SW19.1, SW25.1; also elsewhere on the board
COL1: SW2.1, SW8.1, SW14.1, SW20.1, SW26.1; also elsewhere on the board
COL2: SW3.1, SW9.1, SW15.1, SW21.1, SW27.1; also elsewhere on the board
COL3: SW4.1, SW10.1, SW16.1, SW22.1, SW28.1; also elsewhere on the board
COL4: SW5.1, SW11.1, SW17.1, SW23.1, SW29.1; also elsewhere on the board
COL5: SW6.1, SW12.1, SW18.1, SW24.1, SW30.1; also elsewhere on the board
COL6: SW31.1, SW38.1, SW44.1, SW49.1, SW55.1; also elsewhere on the board
COL7: SW32.1, SW39.1, SW45.1, SW50.1, SW56.1; also elsewhere on the board
COL8: SW33.1, SW40.1, SW46.1, SW51.1, SW57.1; also elsewhere on the board
COL9: SW34.1, SW41.1, SW47.1, SW52.1, SW58.1; also elsewhere on the board
COL10: SW35.1, SW37.1, SW42.1, SW53.1, SW59.1; also elsewhere on the board
COL11: SW36.1, SW43.1, SW48.1, SW54.1, SW60.1; also elsewhere on the board
ROW_L0: D1.3 (K), D2.3 (K), D3.3 (K); also elsewhere on the board
ROW_L1: D7.3 (K), D8.3 (K), D9.3 (K); also elsewhere on the board
ROW_L2: D13.3 (K), D14.3 (K), D15.3 (K); also elsewhere on the board
ROW_L3: D19.3 (K), D20.3 (K), D21.3 (K); also elsewhere on the board
ROW_L4: D25.3 (K), D26.3 (K), D27.3 (K); also elsewhere on the board
ROW_R0: D4.3 (K), D5.3 (K), D6.3 (K); also elsewhere on the board
ROW_R1: D10.3 (K), D11.3 (K), D12.3 (K); also elsewhere on the board
ROW_R2: D16.3 (K), D17.3 (K), D18.3 (K); also elsewhere on the board
ROW_R3: D22.3 (K), D23.3 (K), D24.3 (K); also elsewhere on the board
ROW_R4: D28.3 (K), D29.3 (K), D30.3 (K); also elsewhere on the board

Notes on the sheet:
L3_1 / (blank)
R3_4 / L
L5_6 / Space
R2_5 / P
L1_3 / 2
L1_2 / 1
R4_6 / Sh
R1_5 / 0
R2_1 / Y
R1_6 / -
R5_4 / ←
R3_3 / K
L2_2 / Q
L2_1 / Tab
L4_6 / B
R4_5 / ↑
R3_5 / \
R5_5 / ↓
L5_5 / (blank)
L5_2 / Fn
R4_1 / N
R5_3 / .
L5_4 / LED
R1_2 / 7
BAV70: independent anodes 1 / 2; common cathode 3. Dots are connections; unmarked bus crossings are not connected.
R1_7 / BS
R3_1 / H
R1_4 / 9
L4_1 / Sh
R2_2 / U
R1_1 / 6
L1_4 / 3
Two independent 5x6 matrices / COL0..5 left, COL6..11 right / separate ROW_L and ROW_R
R4_2 / M
L3_4 / D
L2_3 / W
R5_6 / →
L2_5 / R
L4_4 / C
L3_3 / S

Parts:
C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37: 100n; RPI_generic_capc1005x50; voltage 50V; tolerance 10%; manufacturer_pn CL05B104KB54PNC; LCSC C307331
D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46: WS2812B-4020-V6; WS2812B_4020_V6_LCSC_Reference; manufacturer_pn WS2812B-4020-V6; LCSC C52941387
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP13, JP14, JP15, JP16: OPEN; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R24: 100; RPI_generic_resc1005x35; manufacturer_pn 0402WGF1000TCE; LCSC C25076

Connections:
/Side LEDs/LED_CHAIN_01: D31.3 (DOUT), D32.1 (DIN), JP1.2 (B), JP2.1 (A)
/Side LEDs/LED_CHAIN_02: D32.3 (DOUT), D33.1 (DIN), JP2.2 (B), JP3.1 (A)
/Side LEDs/LED_CHAIN_03: D33.3 (DOUT), D34.1 (DIN), JP3.2 (B), JP4.1 (A)
/Side LEDs/LED_CHAIN_04: D34.3 (DOUT), D35.1 (DIN), JP4.2 (B), JP5.1 (A)
/Side LEDs/LED_CHAIN_05: D35.3 (DOUT), D36.1 (DIN), JP5.2 (B), JP6.1 (A)
/Side LEDs/LED_CHAIN_06: D36.3 (DOUT), D37.1 (DIN), JP6.2 (B), JP7.1 (A)
/Side LEDs/LED_CHAIN_07: D37.3 (DOUT), D38.1 (DIN), JP7.2 (B), JP8.1 (A)
/Side LEDs/LED_CHAIN_08: D38.3 (DOUT), D39.1 (DIN), JP8.2 (B), JP9.1 (A)
/Side LEDs/LED_CHAIN_09: D39.3 (DOUT), D40.1 (DIN), JP9.2 (B), JP10.1 (A)
/Side LEDs/LED_CHAIN_10: D40.3 (DOUT), D41.1 (DIN), JP10.2 (B), JP11.1 (A)
/Side LEDs/LED_CHAIN_11: D41.3 (DOUT), D42.1 (DIN), JP11.2 (B), JP12.1 (A)
/Side LEDs/LED_CHAIN_12: D42.3 (DOUT), D43.1 (DIN), JP12.2 (B), JP13.1 (A)
/Side LEDs/LED_CHAIN_13: D43.3 (DOUT), D44.1 (DIN), JP13.2 (B), JP14.1 (A)
/Side LEDs/LED_CHAIN_14: D44.3 (DOUT), D45.1 (DIN), JP14.2 (B), JP15.1 (A)
/Side LEDs/LED_CHAIN_15: D45.3 (DOUT), D46.1 (DIN), JP15.2 (B), JP16.1 (A)
/Side LEDs/LED_CHAIN_16_END: D46.3 (DOUT), JP16.2 (B)
/Side LEDs/LED_DATA_3V3: D31.1 (DIN), JP1.1 (A), R24.2
EXP_GPIO17_3V3: R24.1; also elsewhere on the board
GND: C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, D31.4 (VSS), D32.4 (VSS), D33.4 (VSS), D34.4 (VSS), D35.4 (VSS), D36.4 (VSS), D37.4 (VSS), D38.4 (VSS), D39.4 (VSS), D40.4 (VSS), D41.4 (VSS), D42.4 (VSS), D43.4 (VSS), D44.4 (VSS), D45.4 (VSS), D46.4 (VSS); also elsewhere on the board
VBUS: C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, D31.2 (VDD), D32.2 (VDD), D33.2 (VDD), D34.2 (VDD), D35.2 (VDD), D36.2 (VDD), D37.2 (VDD), D38.2 (VDD), D39.2 (VDD), D40.2 (VDD), D41.2 (VDD), D42.2 (VDD), D43.2 (VDD), D44.2 (VDD), D45.2 (VDD), D46.2 (VDD); also elsewhere on the board

Notes on the sheet:
WING27 / サイドLED 16灯
右側・内向き 4灯
WS2812B-4020-V6：GPIO17 → R24 100Ω → DIN(1)。VDD(2)=VBUS、DOUT(3)、VSS(4)=GND。
順序：左内4 → 左外4 → 右内4 → 右外4。図の左右は信号順を示す。基板の光向きは実装図で確認。
左側・内向き 4灯
各灯100nF / DIN・DOUTは実配線で連鎖。JP1〜16は通常OPEN、部品実装不要。
途中のLEDを外す場合のみ、対応JPを短絡してDIN→DOUTをバイパスする。LED実装中は短絡しない。
右側・外向き 4灯
左側・外向き 4灯
