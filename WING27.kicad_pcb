# Repository HSBL-ko-gyo/WING27 (continued)

## KiCad design WING27.kicad_pcb (continued)

Parts:
C1: 1u; C_0603_1608Metric; manufacturer_pn CL10A105KB8NNNC; LCSC C15849
C3, C4: 15p; RPI_generic_capc1005x50; voltage 50V; tolerance 5%; manufacturer_pn 0402CG150J500NT; LCSC C1548
C5: 4.7u; C_0603_1608Metric; manufacturer_pn CL10A475KO8NNNC; LCSC C19666
C6, C7: 4.7u; RPI_generic_capc1005x50_wide; voltage 6.3V; tolerance 20%; manufacturer_pn GRM155R60J475ME47D; LCSC C82453
C8, C11, C12, C13, C14, C15, C16, C17, C18, C20, C21: 100n; RPI_generic_capc1005x50; voltage 50V; tolerance 10%; manufacturer_pn CL05B104KB54PNC; LCSC C307331
C9, C10: 4.7u; RPI_generic_capc1005x50; voltage 6.3V; tolerance 20%; manufacturer_pn GRM155R60J475ME47D; LCSC C82453
H1, H2, H3, H4: M2 clearance 2.2mm; MountingHole_2.2mm_M2
J1: USB4105-GF-A-060; USB_C_GCT_USB4105_GF_A060_JLC; manufacturer_pn USB4105-GF-A-060; LCSC C3025063
J2: BM03B-SRSS-TB; JST_SH_BM03B-SRSS-TB_1x03-1MP_P1.00mm_Vertical; manufacturer_pn BM03B-SRSS-TB(LF)(SN); LCSC C160389
J3: SWD 2.54 DNP; PinHeader_1x03_P2.54mm_Vertical; not fitted
L1: 3.3uH; RPI_abracon_aota-b201610s3r3-101-t; tolerance 20%; manufacturer_pn AOTA-B201610S3R3-101-T; LCSC C42411119
R2, R4, R6: 1k; RPI_generic_resc1005x35; tolerance 1%; voltage 50V; manufacturer_pn 0402WGF1001TCE; LCSC C11702
R3: 33; RPI_generic_resc1005x35; tolerance 1%; voltage 50V; manufacturer_pn 0402WGF330JTCE; LCSC C25105
R7, R8: 27; RPI_generic_resc1005x35; tolerance 1%; voltage 50V; manufacturer_pn 0402WGF270JTCE; LCSC C25100
R20, R21: 5.1k; RPI_generic_resc1005x35; manufacturer_pn 0402WGF5101TCE; LCSC C25905
R22, R23: 100; RPI_generic_resc1005x35; manufacturer_pn 0402WGF1000TCE; LCSC C25076
SW61: BOOTSEL; SW_SPST_TS-1088-AR02016; manufacturer_pn TS-1088-AR02016; LCSC C720477
SW62: RESET; SW_SPST_TS-1088-AR02016; manufacturer_pn TS-1088-AR02016; LCSC C720477
TP1: VBUS; TestPoint_Pad_D1.5mm
TP2: EXP_GPIO17_3V3; TestPoint_Pad_D1.5mm
TP3: GND; TestPoint_Pad_D1.5mm
U1: RP2354A; RPI_rpi_rp2350a_vias; manufacturer_pn RP2354A; LCSC C41378174
U2: XC6206P332MR-G; XC6206_SOT23_Torex_Reference; manufacturer_pn XC6206P332MR-G; LCSC C5446
U3: USBLC6-2SC6; SOT-23-6; manufacturer_pn USBLC6-2SC6; LCSC C7519
X1: 12MHz; RPI_generic_xtalcc320x250x80-4; tolerance 30ppm; manufacturer_pn ABM8-272-T3; LCSC C20625731

Connections:
/Controller/+1V1: C7.1, C8.1, C10.1, C11.1, L1.1, U1.6 (DVDD), U1.23 (DVDD), U1.39 (DVDD), U1.50 (VREG_FB)
/Controller/+3V3: C5.1, C6.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C20.1, R3.1, U1.1 (IOVDD), U1.11 (IOVDD), U1.20 (IOVDD), U1.30 (IOVDD), U1.38 (IOVDD), U1.44 (ADC_AVDD), U1.45 (IOVDD), U1.49 (VREG_VIN), U1.53 (USB_OTP_VDD), U1.54 (QSPI_IOVDD), U2.2 (VO)
/Controller/BOOT_SWITCH: R6.2, SW61.2
/Controller/CC1: J1.A5 (CC1), R20.1
/Controller/CC2: J1.B5 (CC2), R21.1
/Controller/QSPI_SS: R6.1, U1.60 (QSPI_~SS)
/Controller/RUN: SW62.2, U1.26 (RUN)
/Controller/RUN_SWITCH: R4.1, SW62.1
/Controller/SWCLK: J2.1, J3.1, R22.2
/Controller/SWCLK_MCU: R22.1, U1.24 (SWCLK)
/Controller/SWDIO: J2.3, J3.3, R23.2
/Controller/SWDIO_MCU: R23.1, U1.25 (SWDIO)
/Controller/USB_DM: J1.A7 (D-), J1.B7 (D-), R8.1, U3.3 (I/O2), U3.4 (I/O2)
/Controller/USB_DM_MCU: R8.2, U1.51 (USB_DM)
/Controller/USB_DP: J1.A6 (D+), J1.B6 (D+), R7.1, U3.1 (I/O1), U3.6 (I/O1)
/Controller/USB_DP_MCU: R7.2, U1.52 (USB_DP)
/Controller/VREG_AVDD: C9.1, R3.2, U1.46 (VREG_AVDD)
/Controller/VREG_LX: L1.2, U1.48 (VREG_LX)
/Controller/XIN: C3.1, U1.21 (XIN), X1.1
/Controller/XOUT: R2.1, U1.22 (XOUT)
/Controller/XTAL_OUT: C4.1, R2.2, X1.3
COL0: U1.31 (GPIO19); also elsewhere on the board
COL1: U1.32 (GPIO20); also elsewhere on the board
COL2: U1.33 (GPIO21); also elsewhere on the board
COL3: U1.34 (GPIO22); also elsewhere on the board
COL4: U1.35 (GPIO23); also elsewhere on the board
COL5: U1.36 (GPIO24); also elsewhere on the board
COL6: U1.9 (GPIO6); also elsewhere on the board
COL7: U1.10 (GPIO7); also elsewhere on the board
COL8: U1.12 (GPIO8); also elsewhere on the board
COL9: U1.13 (GPIO9); also elsewhere on the board
COL10: U1.14 (GPIO10); also elsewhere on the board
COL11: U1.15 (GPIO11); also elsewhere on the board
EXP_GPIO17_3V3: TP2.1, U1.28 (GPIO17); also elsewhere on the board
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.2, J2.MP, J3.2, R4.2, R20.2, R21.2, SW61.1, TP3.1, U1.47 (VREG_PGND), U1.61 (GND), U2.1 (GND), U3.2 (GND), X1.2, X1.4; also elsewhere on the board
ROW_L0: U1.37 (GPIO25); also elsewhere on the board
ROW_L1: U1.40 (GPIO26_ADC0); also elsewhere on the board
ROW_L2: U1.41 (GPIO27_ADC1); also elsewhere on the board
ROW_L3: U1.42 (GPIO28_ADC2); also elsewhere on the board
ROW_L4: U1.43 (GPIO29_ADC3); also elsewhere on the board
ROW_R0: U1.2 (GPIO0); also elsewhere on the board
ROW_R1: U1.3 (GPIO1); also elsewhere on the board
ROW_R2: U1.4 (GPIO2); also elsewhere on the board
ROW_R3: U1.5 (GPIO3); also elsewhere on the board
ROW_R4: U1.7 (GPIO4); also elsewhere on the board
VBUS: C1.1, C21.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), TP1.1, U2.3 (VI), U3.5 (VBUS); also elsewhere on the board

Notes on the sheet:
BOOTSEL
DVDD デカップリング / C10 = 4.7uF
RESET
TP2：GPIO17の3.3 Vデータ。R24（100Ω）経由でサイドLEDを駆動。
CC1・CC2は各5.1kΩ。USB給電は5 Vのみ。
取付穴 / M2・非めっき
J3は未実装の代替端子。J2と同時接続しない。
USB直列抵抗
IOVDD デカップリング
SMPS・水晶は公式配置関係を維持。R7/R8はMCUの近くに配置。USB・発熱・突入電流は実機検証が必要。
3.3 V 電源 / XC6206
USB入力 → ESD保護 → 直列抵抗 → MCU。電気接続・部品・PCB配置は変更なし。
USB-C 入力 / USB2.0・ESD保護
12 MHz 水晶
SWD / 1:CLK 2:GND 3:DIO
WING27 / RP2354A コントローラ

Board: 2 copper layers, 185 parts (16 on the bottom side), 123 nets.

File WING27_BOM.csv:

References,Quantity,Value,Manufacturer,MPN,Footprint,LCSC,Assembly,Datasheet
U1,1,RP2354A,Raspberry Pi,RP2354A,WING27:RPI_rpi_rp2350a_vias,C41378174,PCBA,https://datasheets.raspberrypi.com/rp2350/rp2350-datasheet.pdf
L1,1,3.3uH,Abracon,AOTA-B201610S3R3-101-T,WING27:RPI_abracon_aota-b201610s3r3-101-t,C42411119,PCBA,https://abracon.com/datasheets/AOTA-B201610S3R3-101-T.pdf
X1,1,12MHz,Abracon,ABM8-272-T3,WING27:RPI_generic_xtalcc320x250x80-4,C20625731,PCBA,https://abracon.com/datasheets/ABM8-272-T3.pdf
"R2,R4,R6",3,1k,UNI-ROYAL(Uniroyal Elec),0402WGF1001TCE,WING27:RPI_generic_resc1005x35,C11702,PCBA,https://datasheet.lcsc.com/datasheet/pdf/0a975aaa49b7c97f38a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
R3,1,33,UNI-ROYAL(Uniroyal Elec),0402WGF330JTCE,WING27:RPI_generic_resc1005x35,C25105,PCBA,https://datasheet.lcsc.com/datasheet/pdf/0a975aaa49b7c97f38a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
"R7,R8",2,27,UNI-ROYAL(Uniroyal Elec),0402WGF270JTCE,WING27:RPI_generic_resc1005x35,C25100,PCBA,https://datasheet.lcsc.com/datasheet/pdf/0a975aaa49b7c97f38a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
"C3,C4",2,15p,FH (Guangdong Fenghua Advanced Tech),0402CG150J500NT,WING27:RPI_generic_capc1005x50,C1548,PCBA,https://datasheet.lcsc.com/datasheet/pdf/09fe2daf22580a99fa7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
"C6,C7",2,4.7u,Murata Electronics,GRM155R60J475ME47D,WING27:RPI_generic_capc1005x50_wide,C82453,PCBA,https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/G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
"C8,C11,C12,C13,C14,C15,C16,C17,C18,C20,C21,C22,C23,C24,C25,C26,C27,C28,C29,C30,C31,C32,C33,C34,C35,C36,C37",27,100n,Samsung Electro-Mechanics,CL05B104KB54PNC,WING27:RPI_generic_capc1005x50,C307331,PCBA,https://product.samsungsem.com/mlcc/CL05B104KB54PN.do
"C9,C10",2,4.7u,Murata Electronics,GRM155R60J475ME47D,WING27:RPI_generic_capc1005x50,C82453,PCBA,https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/G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
SW61,1,BOOTSEL,XUNPU,TS-1088-AR02016,WING27:SW_SPST_TS-1088-AR02016,C720477,PCBA,https://datasheet.lcsc.com/datasheet/pdf/0475ac02febf455ca9d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
SW62,1,RESET,XUNPU,TS-1088-AR02016,WING27:SW_SPST_TS-1088-AR02016,C720477,PCBA,https://datasheet.lcsc.com/datasheet/pdf/0475ac02febf455ca9d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
J1,1,USB4105-GF-A-060,GCT,USB4105-GF-A-060,WING27:USB_C_GCT_USB4105_GF_A060_JLC,C3025063,PCBA,https://gct.co/files/drawings/usb4105.pdf
"R20,R21",2,5.1k,UNI-ROYAL(Uniroyal Elec),0402WGF5101TCE,WING27:RPI_generic_resc1005x35,C25905,PCBA,https://datasheet.lcsc.com/datasheet/pdf/0a975aaa49b7c97f38a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
U3,1,USBLC6-2SC6,STMicroelectronics,USBLC6-2SC6,WING27:SOT-23-6,C7519,PCBA,https://www.st.com/resource/en/datasheet/usblc6-2.pdf
U2,1,XC6206P332MR-G,Torex Semiconductor,XC6206P332MR-G,WING27:XC6206_SOT23_Torex_Reference,C5446,PCBA,https://product.torexsemi.com/system/files/series/xc6206.pdf
C1,1,1u,Samsung Electro-Mechanics,CL10A105KB8NNNC,WING27:C_0603_1608Metric,C15849,PCBA,https://product.samsungsem.com/mlcc/CL10A105KB8NNN.do
C5,1,4.7u,Samsung Electro-Mechanics,CL10A475KO8NNNC,WING27:C_0603_1608Metric,C19666,PCBA,https://product.samsungsem.com/mlcc/CL10A475KO8NNN.do
J2,1,BM03B-SRSS-TB,JST,BM03B-SRSS-TB(LF)(SN),WING27:JST_SH_BM03B-SRSS-TB_1x03-1MP_P1.00mm_Vertical,C160389,PCBA,https://datasheets.raspberrypi.com/debug/debug-connector-spe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
"SW1,SW2,SW3,SW4,SW5,SW6,SW7,SW8,SW9,SW10,SW11,SW12,SW13,SW14,SW15,SW16,SW17,SW18,SW19,SW20,SW21,SW22,SW23,SW24,SW25,SW26,SW27,SW28,SW29,SW30,SW31,SW32,SW33,SW34,SW35,SW36,SW37,SW38,SW39,SW40,SW41,SW42,SW43,SW44,SW45,SW46,SW47,SW48,SW49,SW50,SW51,SW52,SW53,SW54,SW55,SW56,SW57,SW58,SW59,SW60",60,CMI627301D60,Kailh,CMI627301D60,WING27:Kailh_CMI627301D60,,Hand solder,
"D1,D2,D3,D4,D5,D6,D7,D8,D9,D10,D11,D12,D13,D14,D15,D16,D17,D18,D19,D20,D21,D22,D23,D24,D25,D26,D27,D28,D29,D30",30,BAV70,Jiangsu Changjing Electronics,BAV70,WING27:SOT-23,C68978,PCBA,https://jlcpcb.com/partdetail/BAV70/C68978
"R22,R23,R24",3,100,UNI-ROYAL(Uniroyal Elec),0402WGF1000TCE,WING27:RPI_generic_resc1005x35,C25076,PCBA,https://datasheet.lcsc.com/datasheet/pdf/0a975aaa49b7c97f38a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
J3,1,SWD 2.54 DNP,,,WING27:PinHeader_1x03_P2.54mm_Vertical,,DNP,
"D31,D32,D33,D34,D35,D36,D37,D38,D39,D40,D41,D42,D43,D44,D45,D46",16,WS2812B-4020-V6,Worldsemi,WS2812B-4020-V6,WING27:WS2812B_4020_V6_LCSC_Reference,C52941387,PCBA,https://www.world-semi.com/downloads/datasheets/en/ws2812b-4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

## Code that names these connections

File scripts/audit_electrical.py (part):

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assert upins=={str(i+1):x for i,x in enumerate(pin_names)}
expected_u={str(p):'+3V3' for p in [1,11,20,30,38,44,45,49,53,54]}
expected_u.update({str(p):'+1V1' for p in [6,23,39,50]})
expected_u.update({'46':'VREG_AVDD','47':'GND','48':'VREG_LX','61':'GND','21':'XIN','22':'XOUT','24':'SWCLK_MCU','25':'SWDIO_MCU','26':'RUN','51':'USB_DM_MCU','52':'USB_DP_MCU','60':'QSPI_SS','28':'EXP_GPIO17_3V3'})
expected_u.update({str(p):f'COL{i}' for i,p in enumerate([31,32,33,34,35,36,9,10,12,13,14,15])})
expected_u.update({str(p):f'ROW_L{i}' for i,p in enumerate([37,40,41,42,43])})
expected_u.update({str(p):f'ROW_R{i}' for i,p in enumerate([2,3,4,5,7])})
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
File scripts/redraw_controller.py (part):

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    d.place('R4',279.4,215.9,90)
    d.wire(d.pins('SW62')['1'],d.pins('R4')['1'])
    d.rail('R4','2','GND')
    d.anchors[('reset','RUN')]=d.pins('SW62')['2']

    # Complete the signal paths that were label jumps in the reference.
    qspi = d.anchors[('core', 'QSPI_SS')]
    r6 = d.pins('R6')['1']
    d.wire(qspi, (qspi[0], 80.01), (r6[0], 80.01), r6)
    d.label('QSPI_SS', (r6[0] + 5.08, 80.01))
    for net in ('XIN', 'XOUT'):
        a, b = d.anchors[('core', net)], d.anchors[('crystal', net)]
        d.wire(a, (a[0], b[1]), b)
        d.label(net, b)
    a, b = d.anchors[('core', 'RUN')], d.anchors[('reset', 'RUN')]
    d.wire(a, (a[0], b[1]), b)
    d.label('RUN', b)
    d.label('BOOT_SWITCH', (130.81, 97.79))
    d.label('RUN_SWITCH', (271.78, 215.9), 90)
    d.label('XTAL_OUT', (170.18, 245.11))

    # Pico H-compatible 3-pin debug connector; pin numbers follow the model.
    d.place('J2', 248.92, 238.76, text=((242.57, 229.87), (242.57, 232.41)))
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    d.wire(esd['3'], (311.15, esd['3'][1]), (311.15, 77.47), (331.47, 77.47), (331.47, esd['4'][1]), esd['4'])
    d.wire(esd['1'], d.anchors[('core', 'USB_D+')])
    d.wire(esd['3'], (292.1, esd['3'][1]), (292.1, 74.93), d.anchors[('core', 'USB_D-')])
    d.label('USB_DP', d.anchors[('core', 'USB_D+')])
    d.label('USB_DM', d.anchors[('core', 'USB_D-')])
    d.label('USB_DP_MCU', (246.38, 66.04))
    d.label('USB_DM_MCU', (246.38, 74.93))
    d.wire(esd['5'], (esd['5'][0], 48.26), (302.26, 48.26), d.pins('C21')['1'])
    d.label('VBUS', (302.26, 48.26))
    d.wire(esd['2'], (esd['2'][0], 81.28), (302.26, 81.28), d.pins('C21')['2'])
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    d.place('TP3', 73.66, 83.82, text=((76.2, 80.01), (76.2, 82.55)))
    d.rail('TP3', '1', 'GND')
    d.place('TP2', 222.25, 264.16, text=((226.06, 261.62), (226.06, 264.16)))
    d.wire(d.anchors[('core', 'GPIO17')], d.pins('TP2')['1'])
    d.label('EXP_GPIO17_3V3', d.pins('TP2')['1'])
    for ref in ('TP1', 'TP2', 'TP3'):
        effects = child(prop(d.symbols[ref], 'Value'), 'effects')
        if not child(effects, 'hide'):
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                p[1:3] = [number(v) for v in regular(point(*p[1:3]))[0]]
        elif tag in ('label','global_label','junction','no_connect'):
            at=child(e,'at'); p=point(*at[1:3])
            if tag in ('label','global_label') and (e[1] in usb_names or e[1]=='QSPI_SS'
                or (e[1]=='EXP_GPIO17_3V3' and p == (222.25,264.16))
                or (e[1]=='GND' and p == (238.76,271.78))): continue
            np,mirrored=regular(p); at[1:3]=[number(v) for v in np]
            if mirrored and len(at)>3:
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    # Left-to-right USB chain: receptacle -> ESD -> series R -> MCU pins.
    wire((102.87,86.36), pins('R7')['1'])
    wire((119.38,88.9),(130.81,88.9),(130.81,95.25),pins('R8')['1'])
    for ref,pin,net,yy in [('R7','52','USB_DP_MCU',86.36),('R8','51','USB_DM_MCU',95.25)]:
        a,b=pins(ref)['2'],pins('U1')[pin]
        wire(a,(b[0],yy),b)
        label(net,(259.08,yy))
    label('USB_DP',(149.86,86.36)); label('USB_DM',(149.86,95.25))
    # VBUS physically feeds the left-hand regulator and ESD decoupling.
    wire((55.88,76.2),(55.88,69.85),(20.32,69.85),(20.32,43.18),(54.61,43.18))
    wire((55.88,76.2),(60.96,76.2),(60.96,68.58),(109.22,68.58))
    # BOOTSEL stays on the input side without crossing the USB pair.
    wire((270.51,107.95),(190.5,107.95),(190.5,140.97),(170.18,140.97),pins('R6')['1'])
    label('QSPI_SS',(194.31,107.95))
    # Alternate DNP SWD footprint beside the primary JST connector.
    if 'J3' in symbols:
        wire((316.23,223.52),(355.6,223.52),(355.6,pins('J3')['1'][1]),pins('J3')['1'])
        wire((313.69,226.06),(353.06,226.06),(353.06,pins('J3')['3'][1]),pins('J3')['3'])
        wire(pins('J3')['2'],(358.14,pins('J3')['2'][1])); label('GND',(358.14,pins('J3')['2'][1]))
    wire((304.8,200.66),(304.8,248.92),pins('TP2')['1'])
    label('EXP_GPIO17_3V3',pins('TP2')['1'])

    # Split T branches for KiCad and rebuild dots.  Preserve each existing wire's
    # UUID on its first segment; component/pin/library UUIDs never change.
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
File scripts/build_electrical.py (part):

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 a=child(original_fp[ref],'at');return [float(a[1])+24,float(a[2])-51,float(a[3]) if len(a)>3 else 0]
def pins(lib):
 return [p for s in children(LIB[lib],'symbol') for p in children(s,'pin')]
# Independent halves: left COL0..5=GPIO19..24, ROW_L0..4=GPIO25..29; right COL6..11=GPIO6..11, ROW_R0..4=GPIO0..4. GPIO17 is reserved for extension.
mcu={str(n):'+3V3' for n in [1,11,20,30,38,44,45,49,53,54]}
mcu.update({str(n):'+1V1' for n in [6,23,39,50]});mcu.update({'46':'VREG_AVDD','47':'GND','48':'VREG_LX','61':'GND','21':'XIN','22':'XOUT','24':'SWCLK_MCU','25':'SWDIO_MCU','26':'RUN','51':'USB_DM_MCU','52':'USB_DP_MCU','60':'QSPI_SS'})
for p in pins('RP2354A'):
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for r,v,n,pos,pcb in [('C1','1u','VBUS',(315,75),(138,33,90)),('C5','4.7u','+3V3',(365,75),(144,33,90)),('C21','100n','VBUS',(160,215),(127,32,90))]:
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for r,n,pos,pcb in [('TP1','VBUS',(310,242),(109,67,0)),('TP2','EXP_GPIO17_3V3',(340,242),(113,67,0)),('TP3','GND',(370,242),(117,67,0))]:add(r,'TestPoint',n,mods['TP'],{'1':n},pos,pcb,{'Description':'Power/GPIO test pads; see LED sheet for GPIO17 use.'})
# Matrix: each half has its own five logical row nets. Physical stagger need not equal logical rows.
rows=list(csv.DictReader((ROOT/'reference/P2/Wing27_P2_60_key_center_coordinates_mm.csv').open(encoding='utf-8-sig')))
base=parse((ROOT/'WING27.kicad_sch').read_text());baseSW={prop(s,'Reference')[2]:s for s in children(base,'symbol') if prop(s,'Reference')[2].startswith('SW')}
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  a.append(txt('Official RP2350A Minimal R4-S1 core reused; RP2354A 2MB internal flash, no external flash.',15,15,1.5))
  a.append(txt('Release 8 datasheet: C10=4.7uF at DVDD pin23. Keep L1 marked orientation and official SMPS component relationships.',15,22,1.2))
  a.append(txt('USB-C sink / 5V only. CC1 and CC2 each 5.1k. USB and inrush compliance require firmware + hardware testing.',15,29,1.2))
  a.append(txt('Expansion pads only: no NeoPixel fitted. EXP_GPIO17_3V3 is NOT a 5V-level LED driver.',210,265,1.2))
  a.append(txt('Artwork/unrouted board is user work. Keep USB pair short, matched, continuous ground reference; 27R by MCU.',15,275,1.2))
  # Power flag drivers on rails driven through passive/filter elements.
  for i,net in enumerate(['VBUS','GND','+1V1','VREG_AVDD']):
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